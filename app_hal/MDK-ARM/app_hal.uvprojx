# Keil uVision project app_hal.uvprojx, settings and files
target app_hal (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: app_hal +hex
  AfterMake: E:\soft\keil5\keil5 MDK\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,APP_FREERTOS_TARGET
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../App/Common;../App/Transport;../Hardware/ESP32;../Hardware/WIFI;../Hardware/W5500;../Hardware/SPI;../Hardware/flash;../Middlewares/FreeRTOS;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3;../Interface;interface
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c usart.c spi.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/App
    ../App/: app_freertos.c app_log.c ota_manager.c spi_bus.c uart_bus.c
    ../App/Common/: upgrade_protocol.c crc16_modbus.c crc32.c
  group Application/Transport
    ../App/Transport/: transport_common.c transport_uart.c transport_tcp.c transport_tcp_port_w5500.c transport_wifi.c transport_wifi_port_esp32.c
  group Hardware
    ../Hardware/ESP32/: esp32.c
    ../Hardware/WIFI/: wifi.c
    ../Hardware/W5500/: wizchip_conf.c w5500.c w5500_port.c socket.c
    ../Hardware/SPI/: spi1.c
    ../Hardware/flash/: W25Q32.c
  group Interface
    ./interface/: Int_can.c
    ../Interface/: Int_w24c02.c Int_w25q32.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/source/: tasks.c queue.c list.c event_groups.c stream_buffer.c timers.c croutine.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
